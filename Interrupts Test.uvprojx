# Keil uVision project Interrupts Test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Interrupts Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\UV4;C:\ti\TivaWare_C_Series-2.1.4.178\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Interrupt Test.c
  group Header
    C:/ti/TivaWare_C_Series-2.1.4.178/inc/: hw_memmap.h hw_types.h hw_uart.h
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/: sysctl.h gpio.h
